# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.1.3
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F030x8,USE_FULL_LL_DRIVER
  c include: ..\Drivers\BSP\PY32F030xx_Start_Kit;..\Drivers\PY32F0xx_HAL_Driver\Src;..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\PY32F0xx\Source\arm;..\Drivers\CMSIS\Device\PY32F0xx\Include;..\Drivers\CMSIS\Include;..\Inc;..\Src;..\User;..\User\adc;..\User\exit;..\User\key;..\User\led;..\User\usart;..\User\low_power;..\Drivers\FreeRTOS\include;..\Drivers\FreeRTOS\portable\RVDS\ARM_CM0;..\User\ld2451_radar
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group FreeRTOS
    ../Drivers/FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c stream_buffer.c
    ../Drivers/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../Drivers/FreeRTOS/portable/MemMang/: heap_4.c
  group Common
    ./: startup_py32f030xx.s
    ../User/: system_py32f0xx.c
  group Application/User
    ../User/: py32f0xx_it.c py32f0xx_hal_msp.c main.c
    ../User/adc/: bsp_adc_singleconv_polling.c
    ../User/exit/: bsp_exit.c
    ../User/key/: bsp_gpio_key.c
    ../User/led/: bsp_gpio_led.c
    ../User/usart/: bsp_usart.c
    ../User/spi/: bsp_spi.c
    ../User/mems/: sc7a20h.c vibration_sensor.c
    ../User/low_power/: bsp_low_power.c
    ../User/ld2451_radar/: ld2451_parser.c
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_hal.c py32f0xx_hal_adc.c py32f0xx_hal_adc_ex.c py32f0xx_hal_comp.c py32f0xx_hal_cortex.c py32f0xx_hal_crc.c py32f0xx_hal_dma.c py32f0xx_hal_exti.c py32f0xx_hal_flash.c py32f0xx_hal_gpio.c py32f0xx_hal_i2c.c py32f0xx_hal_irda.c py32f0xx_hal_iwdg.c py32f0xx_hal_led.c py32f0xx_hal_lptim.c py32f0xx_hal_pwr.c py32f0xx_hal_rcc.c py32f0xx_hal_rcc_ex.c py32f0xx_hal_rtc.c py32f0xx_hal_rtc_ex.c py32f0xx_hal_spi.c py32f0xx_hal_tim.c py32f0xx_hal_tim_ex.c py32f0xx_hal_uart.c py32f0xx_hal_usart.c py32f0xx_hal_wwdg.c py32f0xx_ll_adc.c py32f0xx_ll_comp.c py32f0xx_ll_crc.c py32f0xx_ll_dma.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_i2c.c py32f0xx_ll_led.c py32f0xx_ll_lptim.c py32f0xx_ll_pwr.c py32f0xx_ll_rcc.c py32f0xx_ll_rtc.c py32f0xx_ll_spi.c py32f0xx_ll_tim.c py32f0xx_ll_usart.c
  group Doc
    ../: readme.txt
